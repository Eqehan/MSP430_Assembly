<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\jump.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\program_counter_dersi.ewp</path>
  </project>
  <batchBuild/>
</workspace>


