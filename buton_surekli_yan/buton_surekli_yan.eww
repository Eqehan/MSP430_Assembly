<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\buton_surekli_yan.ewp</path>
  </project>
  <batchBuild/>
</workspace>


